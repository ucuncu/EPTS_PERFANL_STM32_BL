# Keil uVision project EPTS_PERFANL_STM_BL.uvprojx, settings and files
target stm32l053 (6120000::V6.12::.\ARMCLANG)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EPTS_PERFANL_STM_BL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 wLevel=3
  c include: .\Source\inc;.\CMSIS\Include;.\CMSIS\Device\ST\STM32L0xx\Include;..\EPTS_PERFANL_STM_BL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ./: main.c
  group source
    ./Source/src/: button.c gpio.c hw.c interrupt.c led.c mma8452q.c cam_m8q.c zigbee.c rtc.c fxas21002.c i2c.c iis2mdc_reg.c systick.c
  group startapp
    ./Source/src/: startup_stm32l053xx.s system_stm32l0xx.c
